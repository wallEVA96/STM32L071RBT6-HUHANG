# Keil uVision project STM32L071RBT6.uvprojx, settings and files
target L071RBT6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L071RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32L071RBT6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L073xx,USE_FULL_LL_DRIVER
  c include: ..\CMSIS\Device\Include;..\CMSIS\Include;..\Inc;..\LL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/Device/Source/: system_stm32l0xx.c startup_stm32l071xx.s
  group LL_Driver
    ../LL_Driver/Src/: stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
  group User
    ../Src/: main.c stm32l0xx_it.c
